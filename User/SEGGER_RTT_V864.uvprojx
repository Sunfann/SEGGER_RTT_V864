# Keil uVision project SEGGER_RTT_V864.uvprojx, settings and files
target SEGGER_RTT_V864 (ARM-ADS)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SEGGER_RTT_V864 (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Config;..\RTT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
